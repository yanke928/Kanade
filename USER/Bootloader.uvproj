# Keil uVision project Bootloader.uvproj, settings and files
target Bootloader (ARM-ADS)
  device: STM32F103RD STMicroelectronics
  cpu: IROM(0x08000000,0x60000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Bootloader +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o .\output\Kanade.bin  .\output\Kanade.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\CMSIS;..\FWlib\inc;..\FWlib\fatfs;..\Source\Main;..\Source\STM32;..\Source\Peripherals\LED;..\Source\Peripherals\RTC;..\Source\Peripherals\Buzzer;..\Source\Peripherals\SSD1306;..\FWlib\sdcard;..\FWlib\usb;..\Source\Bootloader\JumpToApp;..\Source\Bootloader\Peripherals\Key
  memory RVCT4: ROM 0x8000000 size 0x2500
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../CMSIS/startup/: startup_stm32f10x_hd_bootloader.s
  group FWlib
    ../FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_dma.c stm32f10x_spi.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_sdio.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group Main
    ../Source/Bootloader/Main/: Main.c stm32f10x_it.c
  group JumpToApp
    ../Source/Bootloader/JumpToApp/: JumpToApp.c
  group Peripherals
    ../Source/Bootloader/Peripherals/Key/: Keys.c
