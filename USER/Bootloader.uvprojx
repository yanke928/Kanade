# Keil uVision project Bootloader.uvprojx, settings and files
target Bootloader (ARM-ADS)
  device: STM32F103RD STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x60000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Bootloader +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o .\output\Kanade.bin  .\output\Kanade.axf
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\CMSIS;..\FWlib\inc;..\Source\STM32;..\Source\Bootloader\JumpToApp;..\Source\Bootloader\Peripherals\Key;..\Source\Bootloader\Peripherals\sdcard;..\Source\Bootloader\Peripherals\SSD1306;..\Source\Bootloader\Peripherals\W25Q64;..\Source\Bootloader\Main;..\Source\Bootloader\fatfs\include;..\Source\Bootloader\UI;..\Source\Bootloader\Moha2Bin;..\Source\Bootloader\stm32_flash
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ../CMSIS/startup/: startup_stm32f10x_hd_bootloader.s
  group FWlib
    ../FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_dma.c stm32f10x_spi.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_sdio.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group Main
    ../Source/Bootloader/Main/: Main.c stm32f10x_it.c
  group JumpToApp
    ../Source/Bootloader/JumpToApp/: JumpToApp.c
  group Peripherals
    ../Source/Bootloader/Peripherals/Key/: Keys.c
    ../Source/Bootloader/Peripherals/SSD1306/: SSD1306.c
    ../Source/Bootloader/Peripherals/sdcard/: SDCard.c SDCardff.c
    ../Source/Bootloader/Peripherals/W25Q64/: W25Q64.c W25Q64ff.c
  group fatfs
    ../Source/Bootloader/fatfs/source/: diskio.c ff.c ccsbcs.c
  group UI
    ../Source/Bootloader/UI/: UI.c
  group stm32_flash
    ../Source/Bootloader/stm32_flash/: stm32_flash.c
  group Moha2Bin
    ../Source/Bootloader/Moha2Bin/: Moha2Bin.c
software components: CMSIS:CORE 4.3.0
