# Keil uVision project Kanade.uvprojx, settings and files
target Kanade (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RD STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x60000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Kanade +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o .\output\Kanade.bin  .\output\Kanade.axf
  AfterMake: .\FirmwareCreator.exe  .\output\Kanade.bin .\output\Kanade.moha
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\CMSIS;..\FWlib\inc;..\Utilities\STM32_EVAL;..\FWlib\USB\inc;..\Utilities\STM32_EVAL\STM3210C_EVAL;..\Utilities\STM32_EVAL\STM3210B_EVAL;..\FWlib\sdcard;..\FWlib\fatfs;..\Source\Main;..\Source\STM32;..\Source\FreeRTOS\Source\include;..\Source\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\Source\FreeRTOS;..\Source\Peripherals\LED;..\Source\Peripherals\SSD1306;..\Source\Peripherals\Key;..\Source\Startup;..\Source\Peripherals\RTC;..\Source\Peripherals\Temperature_Sensors;..\Source\Peripherals\Buzzer;..\Source\Apps\Music;..\Source\Peripherals\Usarts;..\Source\Peripherals;..\FWlib\sdcard;..\FWlib\usb;..\Source\Apps\USBMeter;..\Source\Apps\Virtual_Clock;..\Source\FreeRTOS_CLI;..\FWlib\usb\inc;..\Source\Apps\CommandLines;..\Source\Apps\BadApplePlayer;..\Source\Apps\CPU_Usage;..\Source\fatfs\include;..\Source\MultiLanguage\LanguageManagement;..\Source\UI;..\Source\Apps\Settings;..\Source\MultiLanguage\ChineseSimplified;..\Source\MultiLanguage\ChineseTraditional;..\Source\MultiLanguage\Japanese;..\Source\Apps\ExceptionHandle;..\Source\Apps\FastChage_Trigger;..\Source\Apps\StepUpTest;..\Source\Apps\LegacyTest;..\Source\Apps\About;..\FWlib\USB\CFG;..\FWlib\USB\CORE;..\Source\Apps\MassStorage;..\Source\Peripherals\W25Q64;..\Source\Peripherals\PWM_Ref;..\Source\Apps\Digital_Load;..\Source\Peripherals\MCP3421;..\Source\Peripherals\FastCharge_Trigger_Circuit;..\Source\Peripherals\Cooling_Fan;..\Source\Apps\SelfTest;..\Source\Peripherals\ADC;..\Source\Drivers\Temperature_Sensors;..\Source\Drivers\DataPins_Voltage_Sensors;..\Source\Drivers\W25Q64;..\Source\Drivers\SD_Card;..\Source\Drivers\LED_Animate;..\Source\Drivers\Digital_Load;..\Source\Apps\Flash_Test;..\Source\Apps\Calibrate;..\Source\Apps\DataPin2Protocol;..\Source\Apps\Digital_Clock;..\Source\Apps\Ripple_Test
  memory RVCT4: ROM 0x8008000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ../Source/Startup/: Startup.c
    ../CMSIS/startup/: startup_stm32f10x_hd.s
  group FWlib
    ../FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_spi.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_sdio.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group Main
    ../Source/Main/: main.c
    ../Source/STM32/: stm32f10x_it.c
  group FreeRTOS
    ../Source/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../Source/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../Source/FreeRTOS/Source/: list.c queue.c tasks.c
    ../Source/FreeRTOS_CLI/: FreeRTOS_CLI.c
  group Peripherals
    ../Source/Peripherals/SSD1306/: SSD1306.c
    ../Source/Peripherals/LED/: LED.c
    ../Source/Peripherals/Key/: Keys.c
    ../Source/Peripherals/RTC/: RTC.c
    ../Source/Peripherals/Buzzer/: Buzzer.c
    ../FWlib/sdcard/: SDCard.c
    ../Source/Peripherals/W25Q64/: W25Q64.c
    ../Source/Peripherals/PWM_Ref/: PWM_Ref.c
    ../Source/Peripherals/MCP3421/: MCP3421.c
    ../Source/Peripherals/FastCharge_Trigger_Circuit/: FastCharge_Trigger_Circuit.c
    ../Source/Peripherals/Cooling_Fan/: Cooling_Fan.c
    ../Source/Peripherals/ADC/: ADC.c
  group Apps
    ../Source/Apps/Music/: Music.c
    ../Source/Apps/USBMeter/: USBMeter.c
    ../Source/Apps/Virtual_Clock/: VirtualRTC.c
    ../Source/Apps/CommandLines/: Command.c
    ../Source/Apps/BadApplePlayer/: BadApplePlayer.c
    ../Source/Apps/CPU_Usage/: CPU_Usage.c
    ../Source/Apps/Settings/: Settings.c
    ../Source/Apps/ExceptionHandle/: ExceptionHandle.c
    ../Source/Apps/FastChage_Trigger/: FastCharge_Trigger.c
    ../Source/Apps/StepUpTest/: StepUpTest.c
    ../Source/Apps/LegacyTest/: LegacyTest.c
    ../Source/Apps/About/: About.c
    ../Source/Apps/MassStorage/: MassStorage.c
    ../Source/Apps/SelfTest/: SelfTest.c
    ../Source/Apps/Flash_Test/: Flash_Test.c
    ../Source/Apps/Calibrate/: Calibrate.c
    ../Source/Apps/DataPin2Protocol/: DataPin2Protocol.c
    ../Source/Apps/Digital_Clock/: Digital_Clock.c
    ../Source/Apps/Ripple_Test/: Ripple_Test.c
  group fatfs
    ../Source/fatfs/source/: ccsbcs.c diskio.c ff.c
  group MultiLanguage
    ../Source/MultiLanguage/LanguageManagement/: MultiLanguageStrings.c Public_FontTab.c
  group UI
    ../Source/UI/: UI_Button.c UI_Dialogue.c UI_Confirmation.c UI_Menu.c UI_Utilities.c UI_Adjust.c UI_ListView.c UI_Dialgram.c UI_ProgressBar.c UI_Print.c UI_Clock.c
  group USB_CORE
    ../FWlib/USB/CORE/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB_CFG
    ../FWlib/USB/CFG/: mass_mal.c hw_config.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group Drivers
    ../Source/Drivers/Temperature_Sensors/: Temperature_Sensors.c
    ../Source/Drivers/DataPins_Voltage_Sensors/: DataPins_Voltage_Sensors.c
    ../Source/Drivers/W25Q64/: W25Q64ff.c
    ../Source/Drivers/SD_Card/: SDCardff.c
    ../Source/Drivers/LED_Animate/: LED_Animate.c
    ../Source/Drivers/Digital_Load/: Digital_Load.c
software components: CMSIS:CORE 4.3.0
