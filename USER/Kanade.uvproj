# Keil uVision project Kanade.uvproj, settings and files
target Kanade (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Kanade +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD,USE_STM3210B_EVAL
  c include: ..\CMSIS;..\FWlib\inc;..\Utilities\STM32_EVAL;..\FWlib\USB\inc;..\Utilities\STM32_EVAL\STM3210C_EVAL;..\Utilities\STM32_EVAL\STM3210B_EVAL;..\FWlib\sdcard;..\FWlib\fatfs;..\Source\Main;..\Source\STM32;..\Source\FreeRTOS\Source\include;..\Source\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\Source\FreeRTOS;..\Source\Peripherals\LED;..\Source\Peripherals\SSD1306;..\Source\Peripherals\Key;..\Source\Startup;..\Source\Peripherals\RTC;..\Source\Peripherals\Temperature_Sensors;..\Source\Peripherals\Buzzer;..\Source\Apps\Music;..\Source\Peripherals\Usarts;..\Source\Protocols\EBD_Protocol;..\Source\Peripherals;..\FWlib\sdcard;..\FWlib\usb;..\Source\Apps\USBMeter;..\Source\Apps\Virtual_Clock;..\Source\FreeRTOS_CLI;..\FWlib\usb\inc;..\Source\Apps\CommandLines;..\Source\Apps\BadApplePlayer;..\Source\Apps\CPU_Usage;..\Source\fatfs\include;..\Source\MultiLanguage\LanguageManagement;..\Source\UI;..\Source\Apps\Settings;..\Source\MultiLanguage\ChineseSimplified;..\Source\MultiLanguage\ChineseTraditional;..\Source\MultiLanguage\Japanese;..\Source\Apps\ExceptionHandle;..\Source\Apps\FastChage_Trigger;..\Source\Apps\StepUpTest
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ../CMSIS/startup/: startup_stm32f10x_md.s
    ../Source/Startup/: Startup.c
  group FWlib
    ../FWlib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_spi.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group Main
    ../Source/Main/: main.c
    ../Source/STM32/: stm32f10x_it.c
  group FreeRTOS
    ../Source/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../Source/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../Source/FreeRTOS/Source/: list.c queue.c tasks.c
    ../Source/FreeRTOS_CLI/: FreeRTOS_CLI.c
  group Peripherals
    ../Source/Peripherals/LED/: LED.c
    ../Source/Peripherals/SSD1306/: SSD1306.c
    ../Source/Peripherals/Key/: Keys.c
    ../Source/Peripherals/RTC/: RTC.c
    ../Source/Peripherals/Temperature_Sensors/: TempSensors.c
    ../Source/Peripherals/Buzzer/: Buzzer.c
    ../Source/Peripherals/Usarts/: Usarts.c
    ../FWlib/sdcard/: SDCard.c SDCardff.c
  group Apps
    ../Source/Apps/Music/: Music.c
    ../Source/Apps/USBMeter/: USBMeter.c
    ../Source/Apps/Virtual_Clock/: VirtualRTC.c
    ../Source/Apps/CommandLines/: Command.c
    ../Source/Apps/BadApplePlayer/: BadApplePlayer.c
    ../Source/Apps/CPU_Usage/: CPU_Usage.c
    ../Source/Apps/Settings/: Settings.c
    ../Source/Apps/ExceptionHandle/: ExceptionHandle.c
    ../Source/Apps/FastChage_Trigger/: FastCharge_Trigger.c
    ../Source/Apps/StepUpTest/: StepUpTest.c
  group Protocols
    ../Source/Protocols/EBD_Protocol/: EBProtocol.c
  group USBVirtualSerial
    ../FWlib/usb/src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c USBCDC.c
    ../FWlib/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group fatfs
    ../Source/fatfs/source/: ccsbcs.c diskio.c ff.c
  group MultiLanguage
    ../Source/MultiLanguage/LanguageManagement/: MultiLanguageStrings.c Public_FontTab.c
  group UI
    ../Source/UI/: UI_Button.c UI_Dialogue.c UI_Confirmation.c UI_Menu.c UI_Utilities.c UI_Adjust.c UI_ListView.c UI_Dialgram.c
